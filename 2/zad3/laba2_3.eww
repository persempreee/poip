<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\POIP-master\ОТЧЕТ2\CPP.3\lr2.ewp</path>
    </project>
    <batchBuild />
</workspace>
